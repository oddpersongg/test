# Keil uVision project project.uvprojx, settings and files
target test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BL_Platform/Common;../BL_Platform/Apdapter;../BL_Platform/Core;../BL_Platform/Config;../CDD/OLED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BL_Platform/Common
    ../BL_Platform/Common/: Bl_Types.h
  group BL_Platform/Apdapter
    ../BL_Platform/Apdapter/: Bl_DriverAdapter.c Bl_DriverAdapter.h Bl_Can.c Bl_Can.h Bl_TaskUserdef.c Bl_TaskUserdef.h Bl_Isr.c Bl_Isr.h
  group BL_Platform/Core
    ../BL_Platform/Core/: Bl_TaskSchedule.c Bl_TaskSchedule.h Bl_Rte.c Bl_Rte.h
  group BL_Platform/Config
    ../BL_Platform/Config/: Bl_TaskSchedule_Lcfg.c Bl_TaskSchedule_Lcfg.h Bl_TaskSchedule_Cfg.h
  group CDD/OLED
    ../CDD/OLED/: OLED.c OLED.h OLED_Font.h
software components: CMSIS:CORE 4.3.0
